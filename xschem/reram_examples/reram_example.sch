** sch_path: xschem/reram_examples/reram_example.sch
**.subckt reram_example
V1 TE 0 PWL (0 0 0.25u 1.4 0.5u 0 0.75u -1.4 1.0u 0.0)
XR0 TE 0 sky130_fd_pr_reram__reram_cell Tfilament_0=3.3e-9
**** begin user architecture code


.tran 0.1n 1.5u



.print tran format=raw file=[file tail [file rootname [xschem get schname]]].raw v(*) i(*)


** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/../xyce/sky130_fd_pr_reram__reram_cell.spice

**** end user architecture code
**.ends
.end
